SUMMARY = "wakeonlan"
HOMEPAGE = "https://pypi.org/project/wakeonlan"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=f8b3f077e531182116789a1d25297f55"

SRC_URI[sha256sum] = "9a2a7cede51e2d4777330592190ea6e8ba391513d74e6f91d3197669cac7c754"
PYPI_PACKAGE = "wakeonlan"

inherit pypi setuptools3

