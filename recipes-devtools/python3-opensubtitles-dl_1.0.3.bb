SUMMARY = "OpenSubtitles dl"
HOMEPAGE = "https://pypi.org/project/opensubtitles-dl/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d2620eff2a5391cb8c491e6a91ce6f19"

SRC_URI[sha256sum] = "dcb8853f450f6e542dbd7cff4fb0b491ab9da11471d80457e0e2fab1a93eadc1"

PYPI_PACKAGE = "opensubtitles-dl"

inherit pypi setuptools3

