SUMMARY = "ansimarkup"
HOMEPAGE = "https://pypi.org/project/ansimarkup"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://README.rst;md5=e6d93e5dafe5d8759d11e4c457e0629c"

SRC_URI[sha256sum] = "96c65d75bbed07d3dcbda8dbede8c2252c984f90d0ca07434b88a6bbf345fad3"

PYPI_PACKAGE = "ansimarkup"

inherit pypi setuptools3

