SUMMARY = "mpd2"
HOMEPAGE = "https://pypi.org/project/mpd2/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://README.rst;md5=adb60549b5601bc569439a4cee936029"

SRC_URI[sha256sum] = "4baec3584cc43ed9948d5559079fafc2679b06b2ade273e909b3582654b2b3f5"

PYPI_PACKAGE = "python-mpd2"

inherit pypi setuptools3

