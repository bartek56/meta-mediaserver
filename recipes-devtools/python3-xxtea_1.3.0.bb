SUMMARY = "xxtea"
HOMEPAGE = "https://pypi.org/project/xxtea/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://README.rst;md5=8a6f95916dd8b031b6a3f350882f1dcf"

SRC_URI[sha256sum] = "0f46a74ad7cfceebba8f23a4f1bedb196f536998417706582441815cbb851d24"

PYPI_PACKAGE = "xxtea"

inherit pypi setuptools3

