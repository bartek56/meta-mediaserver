SUMMARY = "xxtea"
HOMEPAGE = "https://pypi.org/project/xxtea/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://README.rst;md5=f510773874c86df7a90f433edab328ca"

SRC_URI[sha256sum] = "e118e6e8831a4cc4c635d7becd80fab48acefe079667b6282d3f536a1c0bc6ec"

PYPI_PACKAGE = "xxtea"

inherit pypi setuptools3

