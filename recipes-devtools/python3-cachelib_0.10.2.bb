SUMMARY = "wakeonlan"
HOMEPAGE = "https://pypi.org/project/cachelib"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=64768ac879e3507b7e00379a63c2075b"

SRC_URI[sha256sum] = "593faeee62a7c037d50fc835617a01b887503f972fb52b188ae7e50e9cb69740"
PYPI_PACKAGE = "cachelib"

inherit pypi setuptools3

