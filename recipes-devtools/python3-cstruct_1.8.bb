SUMMARY = "cstruct"
HOMEPAGE = "https://pypi.org/project/cstruct/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://README.md;md5=c82719bb922baaf3b4238bc7e88f274d"

SRC_URI[sha256sum] = "e11684fd5e8b9a44834f96dc88293cd7cf5cb393bddee4a9f83ef3f9824bb7af"
PYPI_PACKAGE = "cstruct"

inherit pypi setuptools3

