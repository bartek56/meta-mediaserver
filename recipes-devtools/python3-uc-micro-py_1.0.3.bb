SUMMARY = "Unicode character database for linkify-it-py"
HOMEPAGE = "https://pypi.org/project/uc-micro-py/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2bdce4f0cca8b092dd7889cef7f7fe20"

SRC_URI[sha256sum] = "d321b92cff673ec58027c04015fcaa8bb1e005478643ff4a500882eaab88c48a"

PYPI_PACKAGE = "uc-micro-py"
inherit pypi python_setuptools_build_meta

