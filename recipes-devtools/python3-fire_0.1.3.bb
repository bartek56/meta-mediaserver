SUMMARY = "fire"
HOMEPAGE = "https://pypi.org/project/fire/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ab892b2b62f951d424bdb712a72584cc"

SRC_URI[sha256sum] = "c299d16064ff81cbb649b65988300d4a28b71ecfb789d1fb74d99ea98ae4d2eb"
PYPI_PACKAGE = "fire"

inherit pypi setuptools3

