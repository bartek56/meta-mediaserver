SUMMARY = "OPKG  package managaer - set server"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://opkg.conf"
