PACKAGECONFIG_append = " eglfs accessibility fontconfig gles2 linuxfb tslib"
DEPENDS += "userland"

