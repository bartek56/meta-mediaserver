INSTALL_SCRIPT_NAME = "installScriptQt5.sh"

require recipes-app/configscript/configscript.inc
