INSTALL_SCRIPT_NAME = "installScriptMinimal.sh"

require recipes-app/configscript/configscript.inc
