INSTALL_SCRIPT_NAME = "installScriptBase.sh"

require recipes-app/configscript/configscript.inc
