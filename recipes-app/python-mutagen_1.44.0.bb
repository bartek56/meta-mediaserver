SUMMARY = "Music Metadata"
HOMEPAGE = "https://github.com/quodlibet/mutagen"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI[md5sum] = "ce773321eedcb38b31d0624540191401"

PYPI_PACKAGE = "mutagen"

#PYPI_PACKAGE_EXT = "zip"

inherit pypi setuptools3

